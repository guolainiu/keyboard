## config/boards/arm/nice98/Kconfig.board
```kconfig
# Copyright (c) 2021 Nick Winans
# SPDX-License-Identifier: MIT

config BOARD_NICE98
    bool "nice98"
    depends on SOC_NRF52840_QIAA
```
